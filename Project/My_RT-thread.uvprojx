# Keil uVision project My_RT-thread.uvprojx, settings and files
target RT-thread (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: My_RT-thread
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User;..\rtthread\3.0.3\bsp;..\rtthread\3.0.3\components\finsh;..\rtthread\3.0.3\include;..\rtthread\3.0.3\include\libc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c rtconfig.h
  group rtt/ports
    ../rtthread/3.0.3/libcpu/arm/cortex-m3/: cpuport.c
  group rtt/source
    ../rtthread/3.0.3/src/: thread.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
